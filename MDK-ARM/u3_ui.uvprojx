# Keil uVision project u3_ui.uvprojx, settings and files
target u3_ui (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: u3_ui +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/SDRAM;../Drivers/BSP/sys;../Drivers/BSP/Touch;../Drivers/BSP/SPI;../Drivers/BSP/W25QXX;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\template.sct
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c crc.c dma.c dma2d.c fmc.c iwdg.c ltdc.c rtc.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_sdram.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group gui
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/screen1_screen/: screen1presenter.cpp screen1view.cpp
    ../touchgfx/gui/src/screen_screen/: screenpresenter.cpp screenview.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_iconfont_32_4bpp_28.cpp font_verdana_155_4bpp_0.cpp font_verdana_15_4bpp_0.cpp font_verdana_25_4bpp_0.cpp font_verdana_30_4bpp_0.cpp font_verdana_40_4bpp_0.cpp font_verdana_80_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_iconfont_32_4bpp.cpp kerning_verdana_155_4bpp.cpp kerning_verdana_15_4bpp.cpp kerning_verdana_25_4bpp.cpp kerning_verdana_30_4bpp.cpp kerning_verdana_40_4bpp.cpp kerning_verdana_80_4bpp.cpp table_iconfont_32_4bpp.cpp table_verdana_155_4bpp.cpp table_verdana_15_4bpp.cpp table_verdana_25_4bpp.cpp table_verdana_30_4bpp.cpp table_verdana_40_4bpp.cpp table_verdana_80_4bpp.cpp unmappeddatafont.cpp vectorfontrendererbuffers.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_canrx.cpp image_cpu.cpp image_dianchi64.cpp image_dianci.cpp image_fwtflag.cpp image_fwtqq4.cpp image_g4.cpp image_jzq2.cpp image_jzq3.cpp image_lianjie.cpp image_lunshu.cpp image_oil_box.cpp image_sanzhou.cpp image_seshidu.cpp image_seshidu4.cpp image_sheshidu2.cpp image_sheshidu3.cpp image_signal-4g.cpp image_signal-4g2.cpp image_sxjsd.cpp image_yeyachuangan.cpp svgdatabase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/images/src/__generated/: image_alternate_theme_images_widgets_analogclock_hands_small_hour_plain_dark_accent.cpp image_alternate_theme_images_widgets_imageprogress_plain_thick_tiny.cpp image_alternate_theme_images_widgets_imageprogress_plain_thick_tiny_active.cpp image_alternate_theme_images_widgets_imageprogress_plain_thin_tiny_active.cpp image_alternate_theme_images_widgets_lineprogress_backgrounds_image_styled_batteries_battery_large_0.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/screen1_screen/: screen1viewbase.cpp
    ../touchgfx/generated/gui_generated/src/screen_screen/: screenviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
  group Driver/BSP
    ../Drivers/BSP/SDRAM/: sdram.c
    ../Drivers/BSP/sys/: sys.c
    ../Drivers/BSP/Touch/: ctiic.c ft5206.c
    ../Drivers/BSP/SPI/: spi.c
    ../Drivers/BSP/W25QXX/: w25qxx.c
software components: CMSIS:CORE 5.5.0
